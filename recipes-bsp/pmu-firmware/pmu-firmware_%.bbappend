# Watchdog reset support
YAML_COMPILER_FLAGS:append = " -DENABLE_EM -DENABLE_SCHEDULER -DENABLE_EFUSE_ACCESS -DENABLE_SECURE_VAL=0"
